# Keil uVision project ModBus_Master.uvprojx, settings and files
target ModBus_Master (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BEEP +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\MODBUS_MASTER;..\HARDWARE\TIMER;..\HARDWARE\MODBUS_SLAVE;..\HARDWARE\iic;..\HARDWARE\th_sensor;..\HARDWARE\ADC\ADC;..\HARDWARE\pm_sensor;..\HARDWARE\computer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MODBUS_MASTER/: master.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MODBUS_SLAVE/: slave.c
    ../HARDWARE/iic/: iic.c
    ../HARDWARE/th_sensor/: th_sensor.c
    ../HARDWARE/ADC/ADC/: adc.c
    ../HARDWARE/pm_sensor/: sensor.c
    ../HARDWARE/computer/: computer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c
  group README
    ../: README.TXT
